IMAGE_INSTALL:append = " boot-ready"