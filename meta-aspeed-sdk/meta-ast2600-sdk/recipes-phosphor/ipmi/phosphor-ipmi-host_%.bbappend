FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-BMC-WARM-RESET-Add-the-WARM-RESET-COMMAND-Solution.patch"

